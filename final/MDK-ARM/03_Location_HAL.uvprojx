# Keil uVision project 03_Location_HAL.uvprojx, settings and files
target 03_Location_HAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 03_Location_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../common/debug;../Inf/AT6558R;../Inf/DS3553;../Inf/LLCC68;../Inf/QS_100;../App/communication;../App/lower_power;../App/step_count;../common/tool;../common/config;../common/cjson;..\Inf\LLCC68\E220xMx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c rtc.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ../App/communication/: App_Communication.c
    ../App/step_count/: App_StepCount.c
    ../App/lower_power/: App_LowPower.c
  group Inf/IoT
    ../Inf/QS_100/: Inf_QS100.c
  group Inf/GPS
    ../Inf/AT6558R/: Inf_AT6558R.c
  group Inf/StepCount
    ../Inf/DS3553/: Inf_DS3553.c
  group Inf/LoRa
    ../Inf/LLCC68/: ebyte_core.c Inf_LoRa.c
    ../Inf/LLCC68/E220xMx/: ebyte_callback.c ebyte_e220x.c ebyte_port.c
  group Common
    ../common/debug/: Common_Debug.c
    ../common/tool/: Common_Util.c
    ../common/config/: Common_Config.h
    ../common/cjson/: cJSON.c
software components: CMSIS:CORE 4.3.0
